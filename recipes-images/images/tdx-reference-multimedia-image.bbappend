
IMAGE_INSTALL:append = " avt-csi2 v4l2viewer "
IMAGE_INSTALL:remove = "wayland-qtdemo-launch-cinematicexperience"
